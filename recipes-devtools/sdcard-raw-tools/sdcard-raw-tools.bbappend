FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://01-reduce-sdcard-size.patch;patchdir=${WORKDIR}"