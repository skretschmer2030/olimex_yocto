CORE_IMAGE_EXTRA_INSTALL += " \
    systemd-networkd-conf-olimex \
    "
